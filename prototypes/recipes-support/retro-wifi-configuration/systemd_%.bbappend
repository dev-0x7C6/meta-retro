PACKAGECONFIG:append = " networkd resolved"
RDEPENDS:${PN}:append = " wpa-supplicant"
