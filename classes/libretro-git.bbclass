inherit libretro

S = "${WORKDIR}/git"
SRC_URI = "${LIBRETRO_URI}"
SRCREV ?= "${AUTOREV}"
