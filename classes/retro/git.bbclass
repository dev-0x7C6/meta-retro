#PV_pn-${PN} = "1.0+gitr${SRCPV}"
#PKGV_pn-${PN} = "1.0+gitr${GITPKGV}"
#PR_pn-${PN} = "r100"

