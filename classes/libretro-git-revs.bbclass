# Somewhat tested

LIBRETRO_GIT_REV_pn-81-libretro = "4352130bd2363954262a804b086f86b9d13d97f9"
LIBRETRO_GIT_REV_pn-atari800-libretro = "b0156bf157130aba17a69dcd3d9139e776fbdecb"
LIBRETRO_GIT_REV_pn-beetle-gba-libretro = "135afdbb9591655a3e016b75abba07e481f6d406"
LIBRETRO_GIT_REV_pn-beetle-lynx-libretro = "74dde204c0ec6c4bc4cd7821c14548387fbd9ce8"
LIBRETRO_GIT_REV_pn-beetle-ngp-libretro = "6f15532b6ad17a2d5eb9dc8241d6af62416e796b"
LIBRETRO_GIT_REV_pn-beetle-pce-fast-libretro = "40a42b7f43f029760c92bf0b2097e7d4b90ed29c"
LIBRETRO_GIT_REV_pn-beetle-pcfx-libretro = "7bba6699d6f903bd701b0aa525d845de8427fee6"
LIBRETRO_GIT_REV_pn-beetle-psx-libretro = "0f1e7e60827cad49ebba628abdc83ad97652ab89"
LIBRETRO_GIT_REV_pn-beetle-saturn-libretro = "8a65943bb7bbc3183eeb0d57c4ac3e663f1bcc11"
LIBRETRO_GIT_REV_pn-beetle-supergrafx-libretro = "fadef23d59fa5ec17bc99e1e722cfd9e10535695"
LIBRETRO_GIT_REV_pn-beetle-vb-libretro = "9a4e604a7320a3c6ed30601989fe0bc417fa9ad3"
LIBRETRO_GIT_REV_pn-beetle-wswan-libretro = "5b03d1b09f70dc208387d3c8b59e12e1f0d2692f"
LIBRETRO_GIT_REV_pn-bk-libretro = "626c31596ab3bd62320bd90ea001675d67fd0da9"
LIBRETRO_GIT_REV_pn-bluemsx-libretro = "7a1d40e750860580ab7cc21fbc244b5bc6db6586"
LIBRETRO_GIT_REV_pn-caprice32-libretro = "8681fbdc5623830078b38d713935caf4682e5295"
LIBRETRO_GIT_REV_pn-dinothawr-libretro = "18118f66f4a04897fd1cbbfa87cd8957f5bd22ad"
LIBRETRO_GIT_REV_pn-dosbox-libretro = "e4ed503b14ed59d5d745396ef1cc7d52cf912328"
LIBRETRO_GIT_REV_pn-fbalpha2012-libretro = "fa97cd2784a337f8ac774c2ce8a136aee69b5f43"
LIBRETRO_GIT_REV_pn-fceumm-libretro = "9ed22e5a9a1360a7f599a64283af9fe24b858e3d"
LIBRETRO_GIT_REV_pn-flycast-libretro = "b12f3726d9093acb4e441b1cdcf6cd11403c8644"
LIBRETRO_GIT_REV_pn-fmsx-libretro = "3de916bbf15062de1ab322432d38a1fee29d5e68"
LIBRETRO_GIT_REV_pn-freechaf-libretro = "8e46bf0cfb69fd7b3627f60dcadc96faaaad1fe6"
LIBRETRO_GIT_REV_pn-freeintv-libretro = "45030e10cc1a50cf7a80c5d921aa8cba0aeaca91"
LIBRETRO_GIT_REV_pn-fuse-libretro = "ef603d165914afc3f54971d082e69adea187c8ec"
LIBRETRO_GIT_REV_pn-gambatte-libretro = "132f36e990dfc6effdafa6cf261373432464f9bf"
LIBRETRO_GIT_REV_pn-genesis-plus-gx-libretro = "50551066f71f8a5ea782ea3747891fd6d24ebe67"
LIBRETRO_GIT_REV_pn-gpsp-libretro = "3f2f57c982ffead643957db5b26931df4913596f"
LIBRETRO_GIT_REV_pn-gw-libretro = "819b1dde560013003eeac86c2069c5be7af25c6d"
LIBRETRO_GIT_REV_pn-hatari-libretro = "ec1b59c4b6c7ca7d0d23d60cfe2cb61911b11173"
LIBRETRO_GIT_REV_pn-kronos-libretro = "9be109f9032afa793d2a79b837c4cc232cea5929"
LIBRETRO_GIT_REV_pn-mame-libretro = "ed987ad07964a938351ff3cc1ad42e02ffd2af6d"
LIBRETRO_GIT_REV_pn-mame2000-libretro = "e5d4a934c60adc6d42a3f87319312aad89595a15"
LIBRETRO_GIT_REV_pn-mame2003-libretro = "82596014905ad38c80c9eb322ab08c625d1d92cd"
LIBRETRO_GIT_REV_pn-mame2003-plus-libretro = "0134c428b75882aa474f78dbbf2c6ecde49b97b7"
LIBRETRO_GIT_REV_pn-mame2010-libretro = "d3151837758eade73c85c28c20e7d2a8706f30c6"
LIBRETRO_GIT_REV_pn-mame2015-libretro = "37333ed6fda4c798a1d6b055fe4708f9f0dcf5a7"
LIBRETRO_GIT_REV_pn-mame2016-libretro = "02987af9b81a9c3294af8fb9d5a34f9826a2cf4d"
LIBRETRO_GIT_REV_pn-mgba-libretro = "f87f9ef6cb38537e07dcaedeb82aecac6537d42e"
LIBRETRO_GIT_REV_pn-mrboom-libretro = "c777f1059c9a4b3fcefe6e2a19cfe9f81a13740b"
LIBRETRO_GIT_REV_pn-mupen64plus-libretro = "39b555e52bc8821c15f5aa33e366285cd9272630"
LIBRETRO_GIT_REV_pn-neocd-libretro = "3825848fe7dd7e0ef859729eefcb29e2ea2956b7"
LIBRETRO_GIT_REV_pn-np2kai-libretro = "91e0d0b68022328f3a7fa8ce25269b2c2cc699e6"
LIBRETRO_GIT_REV_pn-nxengine-libretro = "f39250e54f20c616dd4403cb8d4cab14032530b5"
LIBRETRO_GIT_REV_pn-o2em-libretro = "b23a796dd3490e979ff43710317df6d43bd661e1"
LIBRETRO_GIT_REV_pn-opera-libretro = "27bc2653ed469072a6a95102a8212a35fbb1e590"
LIBRETRO_GIT_REV_pn-parallel-n64-libretro = "8fe07c62a364d0af1e22b7f75e839d42872dae7f"
LIBRETRO_GIT_REV_pn-pcsx-rearmed-libretro = "8fda5dd0e28fe46621fb1ab57781c316143017da"
LIBRETRO_GIT_REV_pn-pokemini-libretro = "d2ea2ef52f97ea6f7bfff57b5367d95083474414"
LIBRETRO_GIT_REV_pn-prboom-libretro = "991016b3c7a9c8b0e49b2bc9c72f68c60800fc7b"
LIBRETRO_GIT_REV_pn-prosystem-libretro = "6f7e34aea89db5ba2fbf674e5ff0ad6fc68a198e"
LIBRETRO_GIT_REV_pn-quicknes-libretro = "31654810b9ebf8b07f9c4dc27197af7714364ea7"
LIBRETRO_GIT_REV_pn-snes9x2002-libretro = "a869da7f22c63ee1cb316f79c6dd7691a369da3e"
LIBRETRO_GIT_REV_pn-snes9x2005-libretro = "c216559b9e0dc3d7f059dcf31b813402ad47fea5"
LIBRETRO_GIT_REV_pn-snes9x2010-libretro = "ba9f2240360f8db270fb6ba5465c79c317070560"
LIBRETRO_GIT_REV_pn-stella2014-libretro = "fc87f2c78d3b177f4b9b19698557dce452ac3ce7"
LIBRETRO_GIT_REV_pn-tgbdual-libretro = "9be31d373224cbf288db404afc785df41e61b213"
LIBRETRO_GIT_REV_pn-tyrquake-libretro = "8c6ec56b95860726ab8faae0356751adb90f395c"
LIBRETRO_GIT_REV_pn-vba-next-libretro = "019132daf41e33a9529036b8728891a221a8ce2e"
LIBRETRO_GIT_REV_pn-vecx-libretro = "321205271b1c6be5dbdb8d309097a5b5c2032dbd"
LIBRETRO_GIT_REV_pn-virtualjaguar-libretro = "a162fb75926f5509f187e9bfc69958bced40b0a6"
LIBRETRO_GIT_REV_pn-yabause-libretro = "9be109f9032afa793d2a79b837c4cc232cea5929"
