RRECOMMENDS:${PN}:remove = "weston-init"
