PACKAGECONFIG:append = " kmsdrm"
