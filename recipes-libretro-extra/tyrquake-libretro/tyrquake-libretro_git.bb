DESCRIPTION = "Quake 1 engine - Tyrquake port for libretro"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://gnu.txt;md5=79c2cc4426b9e6f3b9098f02eb47aac1"

inherit libretro-git

LIBRETRO_CORE = "tyrquake"
LIBRETRO_GIT_REPO = "github.com/libretro/tyrquake.git"
