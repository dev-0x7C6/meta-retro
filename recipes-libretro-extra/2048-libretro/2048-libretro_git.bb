DESCRIPTION = "Port of 2048 puzzle game to the libretro API."

LICENSE = "Unlicense"
LIC_FILES_CHKSUM = "file://COPYING;md5=61287f92700ec1bdf13bc86d8228cd13"

inherit libretro

LIBRETRO_CORE = "2048"
LIBRETRO_GIT_REPO = "github.com/libretro/libretro-2048.git"
