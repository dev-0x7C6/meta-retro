DESCRIPTION = "Mr.Boom - 8 players Bomberman clone for libretro."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e7d8cb796ca7b5ac0cdb18c3e2749d97"

inherit libretro

LIBRETRO_CORE = "mrboom"
LIBRETRO_GIT_REPO = "github.com/libretro/mrboom-libretro.git"
