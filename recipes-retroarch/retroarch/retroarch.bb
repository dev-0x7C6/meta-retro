require ${BPN}.inc

RETROARCH_VERSION ?= "1.9.2"

PV = "${RETROARCH_VERSION}-git${SRCPV}"
SRCREV ?= "v${RETROARCH_VERSION}"
