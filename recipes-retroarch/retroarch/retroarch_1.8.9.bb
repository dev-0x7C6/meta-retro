require ${BPN}.inc

RETROARCH_WIFI_PATCHES = ""