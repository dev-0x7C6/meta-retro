DESCRIPTION = "Frodo - Commodore 64 emulator"

LICENSE = "GPL-3.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=0636e73ff0215e8d672dc4c32c317bb3"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/frodo-libretro.git"
