DESCRIPTION = "SHARP X68000 Emulator"

LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://README.MD;md5=c682d0727fafde51bbc866aaa7b5b438"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/px68k-libretro.git"
