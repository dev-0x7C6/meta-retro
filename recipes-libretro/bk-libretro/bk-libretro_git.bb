SUMMARY = "BK-0010/0011/Terak 8510a emulator"
DESCRIPTION = "BK-0010/0011/Terak 8510a emulator"

LICENSE = "BK"
LIC_FILES_CHKSUM = "file://COPYING;md5=6ad70b1941b6bf33cc0bd21a2a7c958b"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/bk-emulator.git"
