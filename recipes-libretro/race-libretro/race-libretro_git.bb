DESCRIPTION = "RACE NGPC emulator"

LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM = "file://license.txt;md5=b234ee4d69f5fce4486a80fdaf4a4263"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/RACE.git"
