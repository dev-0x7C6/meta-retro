require vice-libretro.inc

LIBRETRO_GIT_REPO = "github.com/libretro/vice-libretro.git"
VICE_EMU_TYPE = "xcbm2"
