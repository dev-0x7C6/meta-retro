DESCRIPTION = "Game and Watch simulator"

LICENSE = "Zlib"
LIC_FILES_CHKSUM = "file://LICENSE;md5=04e3156d1bba43f54e5930e75a5271aa"

inherit libretro

LIBRETRO_CORE = "gw"
LIBRETRO_GIT_REPO = "github.com/libretro/gw-libretro.git"
