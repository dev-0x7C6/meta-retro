DESCRIPTION = "Emulator for the Oberon RISC machine"

LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://README.md;md5=8a783be2c538b14ff21ed0821ab3d782"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/oberon-risc-emu.git"
