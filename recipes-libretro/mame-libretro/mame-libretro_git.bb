LICENSE = "MAME"
LIC_FILES_CHKSUM = "file://COPYING;md5=f878ec5dbd711878ea22d64de390c664"

require mame.inc

LIBRETRO_GIT_REPO = "github.com/libretro/mame.git"
