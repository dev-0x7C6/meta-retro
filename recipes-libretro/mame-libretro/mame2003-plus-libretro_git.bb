LICENSE = "MAME"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=60e1e140c3210d8a8741631c9e77f091"

require mame.inc

LIBRETRO_GIT_REPO = "github.com/libretro/${BPN}.git"
