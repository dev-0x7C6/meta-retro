LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

inherit libretro-git

LIBRETRO_CORE = "mame2016"
LIBRETRO_REPO = "github.com/libretro/${BPN}.git"
