LICENSE = "MAME"
LIC_FILES_CHKSUM = "file://${RETRO_LICENSE_DIR}/MAME;md5=801f80980d171dd6425610833a22dbe6"

require mame.inc

LIBRETRO_EXTRA_MAKEFLAGS = " LDFLAGSEMULATOR="${TARGET_LDFLAGS}""

LIBRETRO_GIT_REPO = "github.com/libretro/${BPN}.git"
