DESCRIPTION = "Thomson MO/TO system emulator"

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/Zlika/theodore"
LIBRETRO_CORE = "theodore"

