DESCRIPTION = "Snes9x 2010. Port of Snes9x 1.52+ to Libretro (previously called SNES9x Next). \
Rewritten in C and several optimizations and speedhacks."

LICENSE = "SNES9X"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=82f2245ecff2ebb94c72bbce5002e25c"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/snes9x2010.git"
