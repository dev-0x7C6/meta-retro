DESCRIPTION = "Snes9x 2002. Port of SNES9x 1.39 for libretro (was previously called PocketSNES). \
Heavily optimized for ARM."

LICENSE = "SNES9X"
LIC_FILES_CHKSUM = "file://${RETRO_LICENSE_DIR}/SNES9X;md5=fd974c06a4b28b4f2eaf9e9a96ed92de"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/snes9x2002.git"
