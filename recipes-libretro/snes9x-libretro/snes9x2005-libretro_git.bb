DESCRIPTION = "Snes9x 2005. Port of SNES9x 1.43 for libretro (was previously called CAT SFC)."

LICENSE = "SNES9X"
LIC_FILES_CHKSUM = "file://copyright;md5=027b5432fc7d5926db6b4514c8d49658"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/snes9x2005.git"
