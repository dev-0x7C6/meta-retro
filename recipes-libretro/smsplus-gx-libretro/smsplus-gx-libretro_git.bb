DESCRIPTION = "Sega Master System & Game Gear emu - SMSPlus (enhanced) port for libretro"

LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://docs/license;md5=0636e73ff0215e8d672dc4c32c317bb3"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/smsplus-gx.git"
LIBRETRO_CORE = "smsplus"

