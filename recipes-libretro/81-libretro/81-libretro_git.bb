DESCRIPTION = "Sinclair ZX81 emulator - EightyOne port for libretro"

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=784d7dc7357bd924e8d5642892bf1b6b"

inherit libretro-git

LIBRETRO_CORE = "81"
LIBRETRO_GIT_REPO = "github.com/libretro/81-libretro.git"
