DESCRIPTION = "The Uzebox is a retro-minimalist homebrew game console. It is based on an AVR 8-bit general purpose microcontroller made by Atmel."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://uzem.h;endline=25;md5=332167976fb611036406492df28bcdfe"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/libretro-uzem.git"
