DESCRIPTION = "Neo Geo CD emulator for libretro"

LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=f839e273ca0906304c90b406662bf17a"

inherit libretro-git

LIBRETRO_URI = "gitsm://github.com/libretro/neocd_libretro.git;protocol=https"
LIBRETRO_CORE = "neocd"
