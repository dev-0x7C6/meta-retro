DESCRIPTION = "PICO-8 implementation with SDL2 and RetroArch back-ends"

LICENSE = "GPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/retro8.git"
