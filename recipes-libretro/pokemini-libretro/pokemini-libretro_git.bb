DESCRIPTION = "Pokemon Mini emulator - PokeMini port for libretro"

LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=65d7e3de6ed0d7bb08187100789e7221"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/pokemini.git"
