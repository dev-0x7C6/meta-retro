SUMMARY = "Optimized port of VBA-M to Libretro."

LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=63ecf6d881e3ca7dab50e686948a6286"

inherit libretro

LIBRETRO_GIT_REPO = "github.com/libretro/vba-next.git"
